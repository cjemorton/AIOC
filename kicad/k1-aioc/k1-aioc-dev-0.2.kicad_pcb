# Repository cjemorton/AIOC

## KiCad design kicad/k1-aioc/k1-aioc-dev-0.2.kicad_pcb

Parts:
C1, C2: 22p/NP0; C_0603_1608Metric; LCSC C1653
C3, C8, C9, C12, C15: 100n; C_0603_1608Metric; LCSC C14663
C4, C5, C6, C7, C10, C13, C14: 4.7u/10V/X5R; C_0603_1608Metric; LCSC C19666
C11: 10n/NP0; C_0603_1608Metric; LCSC C57112
D2, D3, D4: LED
FB1, FB2: 600R@100MHz; L_0603_1608Metric; LCSC C1002
H1, H2: ToolingHole; TOOLING-HOLE
J1: HX TYPE-C 24P QCHT; TYPE-C-SMD_TYPE-C-24P-QCHT; LCSC Part C5178545
J2: Conn_01x07_Male; PinHeader_1x07_P1.27mm_Vertical
LED1: XL-1608UGC-04; LED0603-RD_GREEN; LCSC Part C965804
Q1: BC847BS; SOT-363_SC-70-6; LCSC C8653
R1: 1.5K; R_0603_1608Metric; LCSC C22843
R2: 10K; R_0603_1608Metric; LCSC C25804
R3, R6, R7, R16: 5.1K; R_0603_1608Metric; LCSC C23186
R4, R8, R9, R15: 220R; R_0603_1608Metric; LCSC C22962
R5, R10, R11, R14: 2.2K; R_0603_1608Metric; LCSC C4190
R12, R13: 22R; R_0603_1608Metric; LCSC C23345
R17: N.M.; R_0603_1608Metric
U1: MIC5330-SSYML-TR; MLF-8_L2.0-W2.0-P0.50-BL-EP; LCSC Part C144168
U2: STM32F302CBT6; LQFP-48_7x7mm_P0.5mm; LCSC C94046
Y1: 8MHz/20pF; Crystal_SMD_5032-2Pin_5.0x3.2mm; LCSC C115962

Connections:
+3.3VA: C9.1, C10.1, FB1.1, R16.1, U2.9 (VDDA), U2.24 (VDDSD), U2.25 (VREFSD+)
+3V3: C4.1, C7.1, C8.1, J2.7, R1.1, U1.8 (VOUT1), U2.1 (VBAT), U2.17 (VDD), U2.36 (PF7), U2.48 (VDD)
/AFIN: C11.1, R3.2, R5.1, R16.2, U2.20 (PB2)
/AFOUT: R2.2, U2.14 (PA4)
/BOOT0: J2.1, R14.2, U2.44 (BOOT0)
/DAC_ATTEN: R17.2, U2.13 (PA3)
/NRST: C15.1, J2.3, U2.7 (NRST)
/OSCIN: C1.1, U2.5 (PF0), Y1.1
/OSCOUT: C2.1, U2.6 (PF1), Y1.2
/PTT1: R11.1, U2.11 (PA1)
/PTT2: R10.1, U2.10 (PA0)
/RADIO-MIC: C13.2
/RADIO-RX-PTT1: R8.1, R13.1
/RADIO-SPK: C14.2
/RADIO-TX: R9.1
/RADIO-VP-PTT2: R12.1
/SWCLK: J2.6, U2.37 (PA14)
/SWDIO: J2.4, U2.34 (PA13)
/SWO: J2.2, U2.39 (PB3)
/USART-RX: R9.2, U2.31 (PA10)
/USART-TX: R8.2, U2.30 (PA9)
/VBUS: FB2.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
/VIN: C6.1, FB2.2, U1.1 (VIN), U1.4 (EN2), U1.5 (EN1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C15.2, J1.25, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J2.5, Q1.1 (E1), Q1.4 (E2), R3.1, R4.1, R6.1, R7.2, R14.1, U1.2 (GND), U1.9 (EP), U2.8 (VSSA), U2.23 (VSSSD), U2.35 (PF6), U2.47 (VSS)
unnamed: C12.1, C13.1, R2.1, R4.2, R17.1
unnamed: C14.1, R5.2
unnamed 26: D2.1 (K), D3.2 (A), D4.1 (K), U2.46 (PB9); also elsewhere on the board
unnamed 27: D2.2 (A), D3.1 (K), D4.2 (A), R15.1; also elsewhere on the board
unnamed: J1.A5 (CC1), R7.1
unnamed: Q1.2 (B1), R10.2
unnamed: Q1.6 (C1), R12.2
unnamed: Q1.5 (B2), R11.2
unnamed: Q1.3 (C2), R13.2
unnamed: C3.1, U1.3 (BYP)
unnamed: C5.1, FB1.2, U1.7 (VOUT2)
unnamed: R15.2, U2.45 (PB8)

Notes on the sheet:
STM Disco SWD Header
Short Pins for Bootloader
SDADC1_AIN4P/ADC2_IN12
USART1-TX
K connector consists of two TRS connectors (3.5mm and 2.5mm) spaced 12mm apart Upper connector (2.5mm) T: SPK+ R: TxData (from Radio) S: GND Lower connector (3.5mm) T: +V/PTT2 R: MIC+ S: PTT1/RxData (to Radio)
GPIOA P.P.
DAC1_OUT1
MIC5330: dual low-dropout (LDO) linear regulator
GPIOA O.D.
Compatible to STM32F302CBTx (no DS-ADC)
USART1-RX
USB-C: Connector, Using usb 2.0 mode.

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
Board: 2 copper layers, 21.5 x 32.0 mm, 46 parts (2 on the bottom side), 35 nets.

Other parts of the board:
D1: GREEN; LED_0603_1608Metric

Their connections:
unnamed 26: D1.2 (A); also elsewhere on the board
unnamed 27: D1.1 (K); also elsewhere on the board

File kicad/k1-aioc/jlcpcb/production_files-dev-0.1/BOM-k1-aioc.csv:

"Reference","Qty","Value","DNP","Exclude from BOM","Exclude from Board","Footprint","Datasheet"
"C1,C2","2","22p/NP0","","","","Capacitor_SMD:C_0603_1608Metric","~"
"C3,C8,C9,C12,C15","5","100n","","","","Capacitor_SMD:C_0603_1608Metric","~"
"C4,C5,C6,C7,C10,C13,C14","7","4.7u/10V/X5R","","","","Capacitor_SMD:C_0603_1608Metric","~"
"C11","1","10n/NP0","","","","Capacitor_SMD:C_0603_1608Metric","~"
"D1","1","GREEN","","","","LED_SMD:LED_0603_1608Metric","~"
"D2","1","RED","","","","LED_SMD:LED_0603_1608Metric","~"
"D3,D4","2","N.M.","","","","LED_SMD:LED_0603_1608Metric","~"
"FB1,FB2","2","600R@100MHz","","","","Inductor_SMD:L_0603_1608Metric","~"
"H1,H2","2","ToolingHole","","Excluded from BOM","","AIOC:TOOLING-HOLE","~"
"J1","1","12401832E402A","","","","AIOC:USB_C_Receptacle_Amphenol_12401832E40-2A","https://www.usb.org/sites/default/files/documents/usb_type-c.zip"
"J2","1","Conn_01x07_Male","","","","Connector_PinHeader_1.27mm:PinHeader_1x07_P1.27mm_Vertical","~"
"Q1","1","BC847BS","","","","Package_TO_SOT_SMD:SOT-363_SC-70-6","~"
"R1","1","1.5K","","","","Resistor_SMD:R_0603_1608Metric","~"
"R2","1","10K","","","","Resistor_SMD:R_0603_1608Metric","~"
"R3,R6,R7,R16","4","5.1K","","","","Resistor_SMD:R_0603_1608Metric","~"
"R4,R8,R9,R15","4","220R","","","","Resistor_SMD:R_0603_1608Metric","~"
"R5,R10,R11,R14","4","2.2K","","","","Resistor_SMD:R_0603_1608Metric","~"
"R12,R13","2","22R","","","","Resistor_SMD:R_0603_1608Metric","~"
"R17","1","N.M.","","","","Resistor_SMD:R_0603_1608Metric","~"
"U1","1","MIC5330-SSYML","","","","AIOC:Micrel_MLF-8-1EP_2x2mm_P0.5mm_EP0.6x1.2mm","http://ww1.microchip.com/downloads/en/DeviceDoc/mic5330.pdf"
"U2","1","STM32F373CBTx","","","","Package_QFP:LQFP-48_7x7mm_P0.5mm","http://www.st.com/st-web-ui/static/active/en/resource/techni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"
"Y1","1","8MHz/20pF","","","","AIOC:Crystal_SMD_5032-2Pin_5.0x3.2mm","~"

## Commit log

2025-09-01 Changed Component
    Changed the component part numbers with drop in replacements, for price and availability.
2025-09-02 Saved new version of KiCad 9.0
2025-09-02 Added A new Connector
    Added a new connector.
2025-09-03 End of day progress
    End of day progress
2025-09-03 tweaks
    Tweaks and changes.
2025-09-03 renamed branch to cm-dev-0.1
    Renamed branch to cm-dev-0.1 to reflect that these are my changes to the board.
2025-09-03 added my branch tag
    added by github username and branch development tag to differentiate this board and it's changes from the origional.
2025-09-03 Getting order ready for testing
    Getting order ready for testing.
2025-09-03 Ordered this version
    Up she goes.
2025-09-04 Problems with shorts. Working on it.
    Working. On the problem.
